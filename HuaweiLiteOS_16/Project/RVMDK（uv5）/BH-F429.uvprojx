# Keil uVision project BH-F429.uvprojx, settings and files
target HuaweiLiteOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\led;..\..\LiteOS\arch\arm\arm-m\cortex-m4;..\..\LiteOS\arch\arm\arm-m\include;..\..\LiteOS\cmsis\1.0;..\..\LiteOS\cmsis\2.0;..\..\LiteOS\cmsis;..\..\LiteOS\kernel\include;..\..\LiteOS\kernel\base\include;..\..\LiteOS\kernel\extended\include;..\..\LiteOS\OS_CONFIG;..\..\LiteOS\user;..\..\User\usart;..\..\User\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../../HuaweiLiteOS_15/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c
    ../../User/led/: bsp_led.c
    ../../User/Init/: bsp_Init.c
    ../../User/usart/: bsp_debug_usart.c
    ../../User/key/: bsp_key.c
    ../../User/exti/: bsp_exti.c
  group DOC
    ../../: 必读说明.txt
  group LiteOS/cmsis
    ../../LiteOS/arch/arm/arm-m/src/: los_hwi.c
    ../../LiteOS/cmsis/: cmsis_liteos.c
  group LiteOS/kernel
    ../../LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../LiteOS/kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../LiteOS/kernel/base/mem/membox/: los_membox.c
    ../../LiteOS/kernel/base/misc/: los_misc.c
    ../../LiteOS/kernel/base/om/: los_err.c
    ../../LiteOS/kernel/extended/tickless/: los_tickless.c
    ../../LiteOS/kernel/: los_init.c
  group LiteOS/arch
    ../../LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c
    ../../LiteOS/arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
  group LiteOS/config
    ../../LiteOS/OS_CONFIG/: los_builddef.h los_printf.h target_config.h
  group Lite OS/user
    ../../LiteOS/user/: los_usertask.c
